# Keil uVision project project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\Hardware;..\User;..\Drivers\GD32F4xx_standard_peripheral\Include;..\Drivers\CMSIS;..\Drivers\CMSIS\GD\GD32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: systick.c main.c gd32f4xx_it.c
  group CMSIS
    ../Drivers/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../Drivers/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Driver
    ../Drivers/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_rtc.c gd32f4xx_pmu.c
  group Hardware
    ../Hardware/: bsp_DHT11.c bsp_led.c bsp_RTC.c bsp_USART.c lcd.c lcd_init.c
